inherit externalsrc

EXTERNALSRC = "/workspace/one-kvm"
EXTERNALSRC_BUILD = "${WORKDIR}/build"
